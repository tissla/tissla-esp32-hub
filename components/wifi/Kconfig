## components/wifi/Kconfig
```kconfig
menu "WiFi credentials"

config WIFI_SSID
    string "WiFi SSID"
    default ""

config WIFI_PASSWORD
    string "WiFi password"
    default ""

endmenu
```
